# Keil uVision project stm32_mdk.uvproj, settings and files
target stm32_mdk (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_mdk +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\lib\Libraries\CMSIS;..\lib\Libraries\CMSIS\CM3\CoreSupport;..\lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\lib\Libraries\STM32F10x_StdPeriph_Driver\inc;..\usr\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../usr/src/: stm32f10x_it.c main.c delay.c gpio.c rcc.c usart.c rtc.c
  group Lib
    ../lib/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group StartUp
    ../lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../doc/: readme.txt
